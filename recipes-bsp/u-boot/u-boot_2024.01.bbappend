FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\ 
    file://0001-qemu-x86.h-Set-up-environment-for-OSTree-integration.patch \ 
    file://0002-Revert-ide-remove-duplicate-defines-form-include-ata.patch"